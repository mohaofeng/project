# Keil uVision project NRF24L01.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Dx2_4G_V4_15_2Mhz存币_存票卡头 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\WKUP;..\HARDWARE\SPI;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\RFID;..\HARDWARE\TIMER;..\HARDWARE\HC595;..\HARDWARE\wt588d;..\HARDWARE\BEEP;..\HARDWARE\WDG;..\HARDWARE\ST7588;..\HARDWARE\LCD;..\HARDWARE\ST7588;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FramePkg.c queue.c
  group HARDWARE
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RFID/: rc522.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/BEEP/: BEEP.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ST7588/: ST7565r.C
    ../HARDWARE/: exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_bkp.c
